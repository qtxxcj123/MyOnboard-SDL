# Keil uVision project OnBoardSDK_STM32.uvprojx, settings and files
target DJI_LIB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: osdk_stm32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,STM32,STM32F40x,ARM_MATH_CM4,__FPU_PRESENT,USER_DEBUG
  c misc: --exceptions --cpp11 -DFLIGHT_CONTROL_SAMPLE
  c include: ..\Lib\CMSIS\inc;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Bsp;..\..\..\..\osdk-core\api\inc;..\..\..\..\osdk-core\hal\inc;..\..\..\..\osdk-core\protocol\inc;..\..\..\..\osdk-core\platform\STM32\inc;..\..\..\..\osdk-core\utility\inc;..\..\..\..\osdk-core\platform\default\inc;..\FATFS\src;..\Module;..\APP\SDIO
  asm misc: --exceptions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: cppforstm32.cpp main.cpp FlightControlSample.cpp MissionSample.cpp CameraGimbalSample.cpp MobileSample.cpp TelemetrySample.cpp Activate.cpp Receive.cpp
  group Bsp
    ../APP/SDIO/: sdio_sdcard.c
    ../Bsp/: BspUsart.cpp timer.cpp bsp.cpp dma.cpp iwdg.cpp led.cpp rtc.cpp
  group doc
    ../doc/: readme.txt
  group LIB
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Lib/CMSIS/src/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DJIlib
    ../../../../osdk-core/api/src/: dji_error.cpp dji_vehicle.cpp dji_command.cpp dji_camera.cpp dji_control.cpp dji_hotpoint.cpp dji_mfio.cpp dji_mission_manager.cpp dji_mobile_communication.cpp dji_hardware_sync.cpp dji_subscription.cpp dji_ack.cpp dji_waypoint.cpp dji_broadcast.cpp dji_gimbal.cpp dji_virtual_rc.cpp dji_version.cpp dji_mobile_device.cpp
    ../../../../osdk-core/protocol/src/: dji_open_protocol.cpp dji_aes.cpp dji_protocol_base.cpp
    ../../../../osdk-core/hal/src/: dji_hard_driver.cpp dji_memory.cpp dji_thread_manager.cpp dji_log.cpp dji_platform_manager.cpp
    ../../../../osdk-core/utility/src/: dji_singleton.cpp dji_circular_buffer.cpp
    ../../../../osdk-core/platform/STM32/src/: STM32F4SerialDriver.cpp STM32F4DataGuard.cpp
    ../../../../osdk-core/platform/default/src/: dji_memory_default.cpp
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group Module
    ../Module/: ackTool.cpp buffer.cpp crc.cpp list.cpp GetData.cpp basicFunction.cpp
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
